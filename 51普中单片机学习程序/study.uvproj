# Keil uVision project study.uvproj, settings and files
target My Study (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: study +hex
  c flags: Optimize=8 SizeSpeed=1
  group Study
    ./: STARTUP.A51 mian.c i2c.c
